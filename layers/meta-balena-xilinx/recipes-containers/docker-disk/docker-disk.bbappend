SUPERVISOR_REPOSITORY_zedboard-zynq7 = "balena/armv7hf-supervisor"
LED_FILE_zedboard-zynq7 = "/sys/class/leds/ds23/brightness"

SUPERVISOR_REPOSITORY_qemu-zynq7 = "balena/armv7hf-supervisor"

HOSTTOOLS += "docker"